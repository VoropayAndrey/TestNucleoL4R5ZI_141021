# IAR project ANPDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F40_41xxx; DEBUG_ENABLED; HSE_VALUE=25000000; assert_param(expr)=; __SUPPORT_LOW_ENERGY__
  ICCARM.CCDiagSuppress: pa082,pa084,pe186,pa050
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\Platform; ..\..\..\..\Platform\stm32f4xx\CMSIS; ..\..\..\..\Platform\stm32f4xx\Driver\inc; ..\..\..\..\..\Bluetopia\btpskrnl; ..\..\..\..\..\Bluetopia\btpsvend; ..\..\..\..\..\Bluetopia\btvs; ..\..\..\..\..\Bluetopia\hcitrans.dma; ..\..\..\..\..\Bluetopia\include; ..\..\..\..\..\Bluetopia\profiles\gatt\include; ..\..\..\..\..\Bluetopia\profiles\gaps\include; ..\..\..\..\..\Bluetopia\profiles\dis\include; ..\..\..\..\..\Bluetopia\profiles\bas\include; ..\..\..\..\..\Bluetopia\profiles\ans\include; ..\..\..\..\FreeRTOS\include; ..\..\..\..\FreeRTOS\Portable\IAR\ARM_CM3
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\Platform
  OBJCOPY.OOCOutputFile: ANPDemo.bin
  ILINK.IlinkOutputFile: ANPDemo.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Bluetopia\lib\ewarm\Bluetopia.a; ..\..\..\..\..\Bluetopia\profiles\gatt\lib\ewarm\SS1BTGAT.a; ..\..\..\..\..\Bluetopia\profiles\dis\lib\ewarm\SS1BTDIS.a; ..\..\..\..\..\Bluetopia\profiles\gaps\lib\ewarm\SS1BTGAP.a; ..\..\..\..\..\Bluetopia\profiles\ans\lib\ewarm\SS1BTANS.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F40_41xxx; NDEBUG; HSE_VALUE=25000000; assert_param(expr)=; __SUPPORT_LOW_ENERGY__
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\Platform; ..\..\..\..\Platform\stm32f4xx\CMSIS; ..\..\..\..\Platform\stm32f4xx\Driver\inc; ..\..\..\..\..\Bluetopia\btpskrnl; ..\..\..\..\..\Bluetopia\btpsvend; ..\..\..\..\..\Bluetopia\btvs; ..\..\..\..\..\Bluetopia\hcitrans.dma; ..\..\..\..\..\Bluetopia\include; ..\..\..\..\..\Bluetopia\profiles\gatt\include; ..\..\..\..\..\Bluetopia\profiles\gaps\include; ..\..\..\..\..\Bluetopia\profiles\dis\include; ..\..\..\..\..\Bluetopia\profiles\ans\include; ..\..\..\..\FreeRTOS\include; ..\..\..\..\FreeRTOS\Portable\IAR\ARM_CM3
  ICCARM.CCOptLevel: 3
  group Application
    ../../: ANPDemo.c
    ../../../../Platform/: HAL.c
    ../: Main.c
  group Bluetopia
    ../../../../../Bluetopia/btpskrnl/: BTPSKRNL.c
    ../../../../../Bluetopia/btpsvend/: BTPSVEND.c
    ../../../../../Bluetopia/btvs/: BTVS.c
    ../../../../../Bluetopia/hcitrans.dma/: hcitrans.c
  group FreeRTOS
    ../../../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../FreeRTOS/: list.c queue.c tasks.c timers.c
    ../../../../FreeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s
  group STM32_StdPeriph_Lib
    ../../../../Platform/stm32f4xx/Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c
    ../../../../Platform/ewarm/: startup_stm32f40_41xxx.s
    ../../../../Platform/stm32f4xx/CMSIS/: system_stm32f4xx.c
