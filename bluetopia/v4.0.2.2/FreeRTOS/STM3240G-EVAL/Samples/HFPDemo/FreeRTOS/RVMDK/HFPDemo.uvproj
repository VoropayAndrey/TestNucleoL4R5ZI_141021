# Keil uVision project HFPDemo.uvproj, settings and files
target HFPDemo_Debug (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ..\HFPDemo +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,DEBUG_ENABLED,HSE_VALUE=25000000,"assert_param(expr)"=" "
  c misc: --diag_suppress=186,111
  c include: ..;..\..\;..\..\..\..\Platform;..\..\..\..\Platform\audio;..\..\..\..\Platform\stm32f4xx\CMSIS;..\..\..\..\Platform\stm32f4xx\Driver\inc;..\..\..\..\Platform\stm32xg_eval;..\..\..\..\..\Bluetopia\include;..\..\..\..\..\Bluetopia\btpskrnl;..\..\..\..\..\Bluetopia\btpsvend;..\..\..\..\..\Bluetopia\hcitrans.dma;..\..\..\..\..\Bluetopia\btvs;..\..\..\..\FreeRTOS\include;..\..\..\..\FreeRTOS\portable\RVDS\ARM_CM3;..\..\..\..\..\Bluetopia\profiles\HFRE_16\include
  asm include: ..\..\..\..\Platform
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\..\Platform\rvmdk\STM32F407xG.sct
  group Application
    ../: Main.c
    ../../: HFPDemo.c
    ../../../../Platform/: HAL.c
    ../../../../Platform/audio/: AUDIO.c dac_cs43l22.c
  group Bluetopia
    ../../../../../Bluetopia/btpskrnl/: BTPSKRNL.c
    ../../../../../Bluetopia/btpsvend/: BTPSVEND.c
    ../../../../../Bluetopia/btvs/: BTVS.c
    ../../../../../Bluetopia/hcitrans.dma/: HCITRANS.c
  group STM32_StdPeriph_Lib
    ../../../../Platform/stm32f4xx/CMSIS/: system_stm32f4xx.c
    ../../../../Platform/stm32f4xx/Driver/src/: stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_rcc.c stm32f4xx_i2c.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_dma.c misc.c stm32f4xx_adc.c
    ../../../../Platform/rvmdk/: startup_stm32f40_41xxx.s
  group FreeROTS
    ../../../../FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../../../../FreeRTOS/portable/MemMang/: heap_4.c
  group STM32xG_eval
    ../../../../Platform/stm32xg_eval/: stm324xg_eval_ioe.c
  group Libraries
    ../../../../../Bluetopia/lib/rvmdk/: Bluetopia.lib
    ../../../../../Bluetopia/profiles/HFRE_16/lib/rvmdk/: SS1BTHFR.lib
target HFPDemo_Release (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: ..\HFPDemo +hex
  c flags: Optim=4 OneElfS=1
  c define: STM32F40_41xxx,HSE_VALUE=25000000,"assert_param(expr)"=" "
  c misc: --diag_suppress=186,188,4017,111
  c include: as above
  asm include: ..\..\..\..\Platform
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\..\Platform\rvmdk\STM32F407xG.sct
