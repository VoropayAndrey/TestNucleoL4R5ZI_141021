# Keil uVision project PXPDemo.uvproj, settings and files
target PXPDemo_Debug (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ..\PXPDemo +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,DEBUG_ENABLED,HSE_VALUE=25000000,"assert_param(expr)"=" ",__SUPPORT_LOW_ENERGY__
  c misc: --diag_suppress=186
  c include: ..;..\..;..\..\..\..\Platform;..\..\..\..\Platform\stm32f4xx\CMSIS;..\..\..\..\Platform\stm32f4xx\Driver\inc;..\..\..\..\..\Bluetopia\btpskrnl;..\..\..\..\..\Bluetopia\btpsvend;..\..\..\..\..\Bluetopia\btvs;..\..\..\..\..\Bluetopia\hcitrans.dma;..\..\..\..\..\Bluetopia\include;..\..\..\..\..\Bluetopia\profiles\GATT\include;..\..\..\..\..\Bluetopia\profiles\GAPS\include;..\..\..\..\..\Bluetopia\profiles\DIS\include;..\..\..\..\..\Bluetopia\profiles\IAS\include;..\..\..\..\..\Bluetopia\profiles\LLS\include;..\..\..\..\..\Bluetopia\profiles\TPS\include;..\..\..\..\FreeRTOS\include;..\..\..\..\FreeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\..\Platform\rvmdk\STM32F407xG.sct
  group Application
    ../../: PXPDemo.c
    ../: Main.c
    ../../../../Platform/: HAL.c
  group Bluetopia
    ../../../../../Bluetopia/btvs/: BTVS.c
    ../../../../../Bluetopia/btpskrnl/: BTPSKRNL.c
    ../../../../../Bluetopia/btpsvend/: BTPSVEND.c
    ../../../../../Bluetopia/hcitrans.dma/: HCITRANS.c
  group STM32_StdPeriph_Lib
    ../../../../Platform/stm32f4xx/Driver/src/: stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c misc.c stm32f4xx_i2c.c stm32f4xx_spi.c
    ../../../../Platform/stm32f4xx/CMSIS/: system_stm32f4xx.c
    ../../../../Platform/rvmdk/: startup_stm32f40_41xxx.s
  group Libraries
    ../../../../../Bluetopia/lib/rvmdk/: Bluetopia.lib
    ../../../../../Bluetopia/profiles/GATT/lib/rvmdk/: SS1BTGAT.lib
    ../../../../../Bluetopia/profiles/GAPS/lib/rvmdk/: SS1BTGAP.lib
    ../../../../../Bluetopia/profiles/DIS/lib/rvmdk/: SS1BTDIS.lib
    ../../../../../Bluetopia/profiles/TPS/lib/rvmdk/: SS1BTTPS.lib
    ../../../../../Bluetopia/profiles/LLS/lib/rvmdk/: SS1BTLLS.lib
    ../../../../../Bluetopia/profiles/IAS/lib/rvmdk/: SS1BTIAS.lib
  group FreeRTOS
    ../../../../FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group STM32xG_eval
    ../../../../Platform/stm32xg_eval/: stm324xg_eval_ioe.c
target PXPDemo_Release (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: ..\PXPDemo +hex
  c flags: Optim=4 OneElfS=1
  c define: STM32F40_41xxx,NDEBUG,HSE_VALUE=25000000,"assert_param(expr)"=" ",__SUPPORT_LOW_ENERGY__
  c misc: --diag_suppress=186
  c include: ..;..\..;..\..\..\..\Platform;..\..\..\..\Platform\stm32f4xx\CMSIS;..\..\..\..\Platform\stm32f4xx\Driver\inc;..\..\..\..\..\Bluetopia\btpskrnl;..\..\..\..\..\Bluetopia\btpsvend;..\..\..\..\..\Bluetopia\btvs;..\..\..\..\..\Bluetopia\hcitrans.dma;..\..\..\..\..\Bluetopia\include;..\..\..\..\..\Bluetopia\profiles\gatt\include;..\..\..\..\..\Bluetopia\profiles\gaps\include;..\..\..\..\..\Bluetopia\profiles\dis\include;..\..\..\..\..\Bluetopia\profiles\IAS\include;..\..\..\..\..\Bluetopia\profiles\LLS\include;..\..\..\..\..\Bluetopia\profiles\TPS\include;..\..\..\..\FreeRTOS\include;..\..\..\..\FreeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\..\Platform\rvmdk\STM32F407xG.sct
