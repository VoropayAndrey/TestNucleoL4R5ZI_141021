# Keil uVision project A3DPDemo_SNK.uvproj, settings and files
target A3DPDemo_SNK_Debug (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: A3DPDemo_SNK +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,DEBUG_ENABLED,HSE_VALUE=25000000,"assert_param(expr)"=" "
  c misc: --diag_suppress=186,111
  c include: ..;..\..\;..\..\..\..\Platform;..\..\..\..\Platform\audio;..\..\..\..\Platform\stm32f4xx\CMSIS;..\..\..\..\Platform\stm32f4xx\Driver\inc;..\..\..\..\Platform\stm32xg_eval;..\..\..\..\..\Bluetopia\include;..\..\..\..\..\Bluetopia\btpskrnl;..\..\..\..\..\Bluetopia\btpsvend;..\..\..\..\..\Bluetopia\btvs;..\..\..\..\..\Bluetopia\hcitrans.dma;..\..\..\..\..\Bluetopia\profiles\AUDIO\include;..\..\..\..\..\Bluetopia\profiles\A2DP\include;..\..\..\..\..\Bluetopia\profiles\AVCTP\include;..\..\..\..\..\Bluetopia\profiles\AVRCP\include;..\..\..\..\..\Bluetopia\profiles\GAVD\include;..\..\..\..\FreeRTOS\include;..\..\..\..\FreeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\..\Platform\rvmdk\STM32F407xG.sct
  group Application
    ../: Main.c
    ../../: A3DPDemo_SNK.c
    ../../../../Platform/: HAL.c
    ../../../../Platform/audio/: AUDIO.c dac_cs43l22.c
  group Bluetopia
    ../../../../../Bluetopia/btpskrnl/: BTPSKRNL.c
    ../../../../../Bluetopia/btpsvend/: BTPSVEND.c
    ../../../../../Bluetopia/btvs/: BTVS.c
    ../../../../../Bluetopia/hcitrans.dma/: HCITRANS.c
  group STM32_StdPeriph_Lib
    ../../../../Platform/rvmdk/: startup_stm32f40_41xxx.s
    ../../../../Platform/stm32f4xx/Driver/src/: stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_rcc.c stm32f4xx_i2c.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_adc.c misc.c
    ../../../../Platform/stm32f4xx/CMSIS/: system_stm32f4xx.c
  group FreeRTOS
    ../../../../FreeRTOS/: croutine.c timers.c tasks.c queue.c list.c
    ../../../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group STM32xG_eval
    ../../../../Platform/stm32xg_eval/: stm324xg_eval_ioe.c
  group Libraries
    ../../../../../Bluetopia/lib/rvmdk/: Bluetopia.lib
    ../../../../../Bluetopia/profiles/AUDIO/lib/rvmdk/: SS1BTAUD.lib
    ../../../../../Bluetopia/profiles/AVCTP/lib/rvmdk/: SS1BTAVC.lib
    ../../../../../Bluetopia/profiles/AVRCP/lib/rvmdk/: SS1BTAVR.lib
    ../../../../../Bluetopia/profiles/GAVD/lib/rvmdk/: SS1BTGAV.lib
target A3DPDemo_SNK_Release (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: A3DPDemo_SNK +hex
  c flags: Optim=4 OneElfS=1
  c define: STM32F40_41xxx,NDEBUG,HSE_VALUE=25000000,"assert_param(expr)"=" "
  c misc: --diag_suppress=186,111,4017
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\..\Platform\rvmdk\STM32F407xG.sct
