# Keil uVision project SPPDemo.uvproj, settings and files
target SPPDemo_Debug (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ..\SPPDemo +hex
  c flags: Optim=1 OneElfS=1
  c define: DEBUG_ENABLED,HSE_VALUE=25000000,"assert_param(expr)"=" ",STM32F40_41xxx
  c misc: --diag_suppress=186
  c include: ..;..\..\;..\..\..\..\Platform;..\..\..\..\Platform\stm32f4xx\CMSIS;..\..\..\..\Platform\stm32f4xx\Driver\inc;..\..\..\..\..\Bluetopia\include;..\..\..\..\..\Bluetopia\btpskrnl;..\..\..\..\..\Bluetopia\btpsvend;..\..\..\..\..\Bluetopia\hcitrans.dma;..\..\..\..\..\Bluetopia\btvs;..\..\..\..\FreeRTOS\include;..\..\..\..\FreeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\..\Platform\rvmdk\STM32F407xG.sct
  group Application
    ../../../../Platform/: HAL.c
    ../../: SPPDemo.c
    ../: Main.c
  group Bluetopia
    ../../../../../Bluetopia/lib/rvmdk/: Bluetopia.lib
    ../../../../../Bluetopia/btpskrnl/: BTPSKRNL.c
    ../../../../../Bluetopia/btpsvend/: BTPSVEND.c
    ../../../../../Bluetopia/hcitrans.dma/: HCITRANS.c
    ../../../../../Bluetopia/btvs/: BTVS.c
  group STM32_StdPeriph_Lib
    ../../../../Platform/stm32f4xx/Driver/src/: stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c
    ../../../../Platform/stm32f4xx/CMSIS/: system_stm32f4xx.c
    ../../../../Platform/rvmdk/: startup_stm32f40_41xxx.s
  group FreeRTOS
    ../../../../FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
target SPPDemo_Release (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: ..\SPPLEDemo +hex
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG,HSE_VALUE=25000000,"assert_param(expr)"=" ",STM32F40_41xxx
  c misc: --diag_suppress=186,4017
  c include: ..;..\..\;..\..\..\..\Platform;..\..\..\..\Platform\stm32f4xx\CMSIS;..\..\..\..\Platform\stm32f4xx\Driver\inc;..\..\..\..\..\Bluetopia\btvs;..\..\..\..\..\Bluetopia\include;..\..\..\..\..\Bluetopia\btpskrnl;..\..\..\..\..\Bluetopia\btpsvend;..\..\..\..\..\Bluetopia\hcitrans.dma;..\..\..\..\FreeRTOS\include;..\..\..\..\FreeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\..\Platform\rvmdk\STM32F407xG.sct
